# Keil uVision project del_n_byte.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: del_n_byte +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: del_n_byte.a51
