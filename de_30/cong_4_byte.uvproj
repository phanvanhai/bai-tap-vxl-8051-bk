# Keil uVision project cong_4_byte.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: cong_4_byte
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: cong_4_byte.a51
