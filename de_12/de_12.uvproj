# Keil uVision project de_12.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: de_12
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: de_12.a51
