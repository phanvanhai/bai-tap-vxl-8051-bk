# Keil uVision project R0x2BYTE.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: R0x2BYTE
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: R0x2_byte.a51
